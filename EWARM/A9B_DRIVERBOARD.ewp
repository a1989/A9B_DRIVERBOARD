# IAR project A9B_DRIVERBOARD.ewp, settings and files
configuration s-sclucky-step-driver (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../hwr1001; ../hwr1001/motor; ../hwr1001/pid; ../hwr1001/at24c512; ..\hwr1001\at93c66b
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A9B_DRIVERBOARD.hex
  ILINK.IlinkOutputFile: A9B_DRIVERBOARD.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: adc.c can.c dma.c gpio.c i2c.c iwdg.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group Application/User/hwr1001
    ../hwr1001/: bsp.c control.c core_technology.c delay.c interrupt.c
    ../hwr1001/pid/: pid.c
  group Application/User/hwr1001/bsp
    ../hwr1001/at24c512/: at24c512.c
    ../hwr1001/at93c66b/: at93c66b.c
    ../hwr1001/motor/: drv8711.c TMC2590.c
    ../hwr1001/: led.c
  group Application/User/hwr1001/motor
    ../hwr1001/motor/: encoder.c motor.c timer.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
